# Keil uVision project exercise1.uvproj, settings and files
target LPC2378 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC2378 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: exercise1 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group System settings
    ./: LPC2300.s
  group Program code
    ./: MCB2300 evaluationboard.c LCD_4bit.c assignement2.c Timer0.c hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c LM95071.c
